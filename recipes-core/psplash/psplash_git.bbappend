# look here for files before anywhere else

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
