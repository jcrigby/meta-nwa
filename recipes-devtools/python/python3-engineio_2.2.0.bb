inherit pypi setuptools3
require python-engineio.inc
