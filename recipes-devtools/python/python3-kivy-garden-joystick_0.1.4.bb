inherit python3-dir
require python-kivy-garden-joystick.inc
