inherit python-dir
require python-kivy-garden-joystick.inc
