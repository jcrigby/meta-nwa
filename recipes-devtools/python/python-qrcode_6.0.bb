require python-qrcode.inc
inherit setuptools
