require python-pygments.inc
inherit setuptools
