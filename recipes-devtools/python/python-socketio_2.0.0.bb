inherit pypi setuptools
require python-socketio.inc
