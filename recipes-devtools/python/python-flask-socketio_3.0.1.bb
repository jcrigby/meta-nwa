inherit pypi setuptools
require python-flask-socketio.inc
