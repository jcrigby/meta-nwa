require python-pillow.inc
inherit setuptools
