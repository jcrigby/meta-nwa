inherit pypi setuptools
require python-engineio.inc
