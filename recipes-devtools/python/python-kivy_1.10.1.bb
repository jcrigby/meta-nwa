inherit distutils
require python-kivy.inc
