inherit pypi setuptools3
require python-flask-socketio.inc
