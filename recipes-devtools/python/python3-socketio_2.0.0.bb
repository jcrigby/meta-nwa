inherit pypi setuptools3
require python-socketio.inc
