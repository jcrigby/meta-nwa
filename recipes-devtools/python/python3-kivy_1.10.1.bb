inherit distutils3
require python-kivy.inc
