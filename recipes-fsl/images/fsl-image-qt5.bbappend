QT5_IMAGE_INSTALL_append = " qtdemo"
